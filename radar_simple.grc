options:
  parameters:
    author: ee24m312
    generate_options: qt_gui
    id: radar_simple
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: chirp_bw
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: chirp_period
  id: variable
  parameters:
    value: '1e-3'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: fs_beat
  id: variable
  parameters:
    value: samp_rate/50
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6/2
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '80'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1/chirp_period
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: '1024'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1.0'
    samp_rate: samp_rate
    sensitivity: 2 * 3.14159 * chirp_bw / samp_rate
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, fft_size=1024):
              gr.sync_block.__init__(
                  self,
                  name='Presence Detector',
                  in_sig=[(np.float32, fft_size)],
                  out_sig=[np.float32]
              )
              self.fft_size = fft_size

          def work(self, input_items, output_items):
              vec = input_items[0][0].copy()
              mid = self.fft_size // 2

              # DC leakage ignore — bins mid±10
              vec[mid+20:mid+200] = 0

              # Target zone: bins mid+5 to mid+30
              # (covers ~500 Hz to 3000 Hz = 0 to ~6 m range)
              band = vec[mid+5:mid+30]
              peak = np.max(band)

              # Threshold: tune with empty room first
              # Step 1: Run empty room, note max peak → that is noise floor
              # Step 2: Set threshold = noise_floor * 3
              threshold = -10.0  # tune experimentally
              detected = 1.0 if peak > threshold else 0.0

              output_items[0][0] = np.float32(detected)
              return 1
    fft_size: '1024'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, fft_size=1024, fs_beat=10000.0, chirp_bw=20e6, chirp_period=1e-3):
              gr.sync_block.__init__(
                  self,
                  name='Presence Detector',
                  in_sig=[(np.float32, fft_size)],
                  out_sig=[np.float32]
              )

              self.fft_size = fft_size
              self.fs_beat = fs_beat
              self.chirp_bw = chirp_bw
              self.chirp_period = chirp_period

              self.c = 3e8
              self.slope = chirp_bw / chirp_period

              self.noise_vals = []
              self.cal_count = 0
              self.cal_frames = 20

              self.th_on = None
              self.th_off = None

              self.state = 0
              self.detect_count = 0
              self.clear_count = 0

              self.last_print_range = -1.0

          def work(self, input_items, output_items):
              vec = input_items[0][0].copy()
              mid = self.fft_size // 2

              # Remove DC / leakage near center
              vec[mid-4:mid+4] = 0

              # Search region: adjust as needed
              start_bin = mid + 1
              stop_bin = mid + 80
              band = vec[start_bin:stop_bin]

              # Peak bin in selected band
              k_local = int(np.argmax(band))
              peak = float(band[k_local])
              k = start_bin + k_local

              # Initial calibration
              if self.cal_count < self.cal_frames:
                  self.noise_vals.append(peak)
                  self.cal_count += 1
                  output_items[0][0] = np.float32(0.0)
                  return 1

              # Set thresholds once
              if self.th_on is None:
                  nf = float(np.mean(self.noise_vals))
                  self.th_on = nf * 2.5
                  self.th_off = nf * 1.5
                  print(f"[Radar] Noise floor linear: {nf:.6f}")
                  print(f"[Radar] Detect threshold: {self.th_on:.6f}")
                  print(f"[Radar] Clear threshold: {self.th_off:.6f}")

              # Hysteresis detection
              if self.state == 0:
                  if peak > self.th_on:
                      self.detect_count += 1
                  else:
                      self.detect_count = 0

                  if self.detect_count >= 3:
                      self.state = 1
                      self.detect_count = 0
                      self.clear_count = 0
                      print("Detected")

              else:
                  if peak < self.th_off:
                      self.clear_count += 1
                  else:
                      self.clear_count = 0

                  if self.clear_count >= 8:
                      self.state = 0
                      self.clear_count = 0
                      self.detect_count = 0
                      self.last_print_range = -1.0
                      print("Not Detected")

              # Range estimation only if detected
              if self.state == 1:
                  # Parabolic interpolation around peak for smoother bin estimate
                  if 1 <= k < self.fft_size - 1:
                      y1 = vec[k - 1]
                      y2 = vec[k]
                      y3 = vec[k + 1]
                      denom = 2.0 * (2.0 * y2 - y1 - y3)

                      if abs(denom) > 1e-12:
                          delta = (y3 - y1) / denom
                          delta = max(min(delta, 0.5), -0.5)
                      else:
                          delta = 0.0
                  else:
                      delta = 0.0

                  k_est = k + delta

                  # FFT bin -> beat frequency
                  fb = ((k_est - mid) * self.fs_beat) / self.fft_size

                  # Beat frequency -> distance
                  dist_m = (self.c * abs(fb)) / (2.0 * self.slope)

                  # Print only when distance changes enough
                  if self.last_print_range < 0 or abs(dist_m - self.last_print_range) > 0.10:
                      print(f"Detected | Distance: {dist_m:.2f} m | Beat: {fb:.1f} Hz | Bin: {k_est:.2f}")
                      self.last_print_range = dist_m

              output_items[0][0] = np.float32(self.state)
              return 1
    chirp_bw: chirp_bw
    chirp_period: chirp_period
    fft_size: '1024'
    fs_beat: fs_beat
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '0'
    name: '"Object Detected (1=YES 0=NO)"'
    type: float
    update_time: '0.05'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"Detection Spectrum"'
    vlen: '1024'
    x_axis_label: '"Bin"'
    x_start: '0'
    x_step: '1'
    y_axis_label: '"Power (dB)"'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    clock_source0: internal
    dev_args: master_clock_rate=16e6,num_send_frames=1024
    gain0: tx_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    clock_source0: internal
    dev_args: master_clock_rate=16e6,num_recv_frames=1024
    gain0: rx_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_vco_c_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_vco_c_0, '0', uhd_usrp_sink_0, '0']
- [dc_blocker_xx_0, '0', blocks_stream_to_vector_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_1, '0', qtgui_number_sink_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [filter_fft_low_pass_filter_0, '0', dc_blocker_xx_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_conjugate_cc_0, '0']

metadata:
  file_format: 1
